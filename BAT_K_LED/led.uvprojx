# Keil uVision project led.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BAT32A239KK80FA Cmsemicon
  pack: Cmsemicon.BAT32A239.1.0.00
  cpu: IRAM(0x20000000,0x08000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: led
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,BAT32G139_80PIN
  c include: .\Device\Include;.\Driver\include;.\app\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./app/Source/: delay_dm.c led.c main.c
  group bsp
    ./Driver/src/: gpio.c delay.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
